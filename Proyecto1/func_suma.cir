** func_suma **
*
* NI Multisim to SPICE Netlist Export
* Generated by: berta
* Wed, Dec 15, 2021 11:15:36
*

*## Multisim Component U1 ##*
xU1 0 1 out 3T_VirtualU1 PARAMS: Vos=0 Ib=0 Ioff=0 Av=200000 BW=100000000 Rin=3000000 Rout=10 Vpos=12 Vneg=-12

.SUBCKT 3T_VirtualU1 in_pos in_neg out PARAMS: Av=500k BW=10Meg Rin=10Meg Rout=0 Vos=0 Ib=0 Ioff=0 Vpos=15 Vneg=-15

* Input Stage: Rin, Ibias, Voffset
Vos in_pos 4 {Vos}
Ibias1 4 0 {Ib}
Ibias2 in_neg 0 {Ib}
Ios 4 in_neg {Ioff/2}
Rin 4 in_neg {Rin}

*Middle stage: Gain, frequency, voltage limiting
Bgain 0 6 I={v(4,in_neg)*Av/1meg }
R1 6 0 1meg
CP1 6 0 {Av/(2*pi*1meg*BW)}

Vpos 9 0 {Vpos}
Dlimit_pos 6 9 d1

Vneg 10 0 {Vneg}
Dlimit_neg 10 6 d1

.model d1 d(n=0.1)

*Output stage: Buffer, output resistance
E2 7 0 6 0 1
Rout 7 out {Rout}
.ends

*## Multisim Component R3 ##*
rR3 1 out 1000 vresR3
.model vresR3 r(TC1=0 TC2=0 )

*## Multisim Component R2 ##*
rR2 b 1 1000 vresR2
.model vresR2 r(TC1=0 TC2=0 )

*## Multisim Component R1 ##*
rR1 a 1 1000 vresR1
.model vresR1 r(TC1=0 TC2=0 )
